# Repository TadasBruzas91/side-markers-blinker

File README.md:

# side-markers-blinker
Trailer side markers blink with blinker, but not blink with hazzard lights.
## Tested on bench
Everything works as expected.
## Tested on vechicle
Work when lights is off. 
When lights on in circuit I found high frequency noise, I think this noise is from light bulb check, but I am not sure.

## KiCad design side-markers-blinker.kicad_pcb

Parts:
C1, C2: 100uF; CP_Radial_D5.0mm_P2.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: D_DO-41_SOD81_P7.62mm_Horizontal
H1: MountingHole_Pad; MountingHole_6mm_Pad
J1: Conn_01x07_Socket; TE_826576-7_1x07_P3.96mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6: BC547; TO-92_Inline
Q7, Q8: IRF4905; TO-220-3_Horizontal_TabDown
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
+24v when igniton on: J1.7, Q7.3 (S), Q8.3 (S), R11.2, R13.2
AND gate: D3.1 (K), D4.1 (K), Q3.1 (C)
Blinker signal L input: D2.2 (A), J1.3, R8.1
Blinker signal R input: D1.2 (A), J1.2, R7.1
GND: C1.2, C2.2, H1.1, J1.1, Q1.3 (E), Q2.3 (E), Q4.3 (E), Q5.3 (E), Q6.3 (E)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.2 (A), D5.2 (A), D7.2 (A), R1.2
unnamed: D4.2 (A), D6.2 (A), D8.2 (A), R2.2
unnamed: C1.1, D5.1 (K), R5.1
unnamed: C2.1, D6.1 (K), R6.1
unnamed: D7.1 (K), D9.1 (K), R9.1
unnamed: D9.2 (A), Q1.1 (C), R3.2
unnamed: D10.2 (A), Q2.1 (C), R4.2
unnamed: D8.1 (K), D10.1 (K), R10.1
unnamed: Q1.2 (B), R5.2
unnamed: Q2.2 (B), R6.2
unnamed: Q3.2 (B), R7.2
unnamed: Q3.3 (E), Q4.1 (C)
unnamed: Q4.2 (B), R8.2
unnamed: Q5.2 (B), R9.2
unnamed: Q5.1 (C), R12.2
unnamed: Q6.2 (B), R10.2
unnamed: Q6.1 (C), R14.2
unnamed: Q7.1 (G), R11.1, R12.1
unnamed: Q8.1 (G), R13.1, R14.1
Side marker lamp +24 L output: J1.6, Q8.2 (D)
Side marker lamp +24 R output: J1.5, Q7.2 (D)
Side markers signal input: J1.4, R3.1, R4.1

Notes on the sheet:
AND gate
Right side circuit
Connectors
Left side circuit

Board: 2 copper layers, 69.0 x 66.5 mm, 36 parts (0 on the bottom side), 29 nets.

## Commit log

2023-05-21 Add freecad not required files to gitignore.
2023-05-21 Add grid origin to kicad pcb.
2023-05-21 Build case for pcb.
2023-05-21 Update readme file.
2023-05-25 Reduce board size.
2023-05-25 Remove unnecesary conections.
2023-05-26 Redesigned pcb to use p channel mosfets.
2023-05-26 Add new pcb to the case.
2023-05-26 Updated schematic.
2023-06-07 Fixed mosfet connection.
2023-06-07 Change capacitor value.
2023-06-07 Update readme.
